FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://egalaxy_touch_usb.cfg"
# SRC_URI += " file://some-patch.patch "

