SUMMARY = "Linux timerfd bindings for python"
HOMEPAGE = "https://github.com/FrankAbelbeck/pytimerfd"

LICENSE = "LGPL-3.0-only"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/LGPL-3.0-only;md5=bfccfe952269fff2b407dd11f2f3083b"

SRC_URI[sha256sum] = "513ed0ea275537385795bbf5fe5934229c5bcb8fae3eed79dc7c6d3e1e00477c"

inherit pypi setuptools3
