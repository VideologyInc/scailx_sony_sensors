FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# SRC_URI += "file://0015-change-csi2-sam-interface-mode.patch"
